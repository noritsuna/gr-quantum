options:
  parameters:
    author: Noritsuna Imamura(noritsuna@siprop.org)
    generate_options: qt_gui
    id: one_qubit_simultor_simple
    output_language: python
    title: Simple 1Qubit Simultor
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: quantum_controllers_Analyzer_0
  id: quantum_controllers_Analyzer
  parameters:
    amp_threshold_rate: '50.0'
    bw_threshold_rate: '10.0'
    freq_threshold_rate: '10.0'
    proc_time_threshold_rate: '10.0'
    qubit_num: '1'
    samples_per_second: samp_rate
    scale_rate: '1000000000.0'
    showSyncPort: 'False'
  states: {}
- name: quantum_controllers_Coprocessor_0
  id: quantum_controllers_Coprocessor
  parameters:
    qubit_id: '0'
    samples_per_second: samp_rate
    scale_rate: '1000000000.0'
    showSyncPort: 'True'
  states: {}
- name: quantum_controllers_Generator_0
  id: quantum_controllers_Generator
  parameters:
    qubit_num: '1'
    samples_per_second: samp_rate
    scale_rate: '1000000000.0'
    showSyncPort: 'False'
  states: {}
- name: quantum_controllers_Initializer_0
  id: quantum_controllers_Initializer
  parameters:
    I_amp: '0.1'
    I_bw: '10'
    Q_amp: '0.01'
    Q_bw: '20'
    freq: '1000'
    isFeedbackMode: 'False'
    proc_time: '3'
    qubit_id: '1'
    samples_per_second: samp_rate
  states: {}
- name: quantum_controllers_QuTiP_Simulator_0
  id: quantum_controllers_QuTiP_Simulator
  parameters:
    qubit_noise_rate: '0.0'
    qubit_num: '1'
    scale_rate: '1000000000.0'
  states: {}
- name: quantum_controllers_readout_0
  id: quantum_controllers_readout
  parameters:
    I_amp: '0.008'
    I_bw: '50'
    Q_amp: '1.0'
    Q_bw: '80'
    freq: '1500'
    proc_time: '4'
    samples_per_second: samp_rate
  states: {}
- name: quantum_gates_X_0
  id: quantum_gates_X
  parameters:
    I_amp: '0.04'
    I_bw: '30'
    Q_amp: '0.6'
    Q_bw: '50'
    freq: '1200'
    proc_time: '5'
    samples_per_second: samp_rate
  states: {}
- name: quantum_measurements_Detector_0
  id: quantum_measurements_Detector
  parameters:
    amp_threshold_rate: '10.0'
    bw_threshold_rate: '10.0'
    freq_threshold_rate: '10.0'
    proc_time_threshold_rate: '10.0'
    qubit_num: '1'
    qubit_pole: 'True'
    samples_per_second: samp_rate
    scale_rate: '1000000000.0'
  states: {}
- name: quantum_viewer_QuTiP_Bloch_0
  id: quantum_viewer_QuTiP_Bloch
  parameters:
    qubit_id: '1'
  states: {}

connections:
- [quantum_controllers_Analyzer_0, analyzed_data, blocks_message_debug_0, print]
- [quantum_controllers_Analyzer_0, analyzed_data, quantum_controllers_QuTiP_Simulator_0, analyzed_data]
- [quantum_controllers_Analyzer_0, out, blocks_message_debug_0, print]
- [quantum_controllers_Analyzer_0, out, quantum_controllers_QuTiP_Simulator_0, in]
- [quantum_controllers_Coprocessor_0, '0', quantum_controllers_Analyzer_0, '0']
- [quantum_controllers_Coprocessor_0, '1', quantum_controllers_Analyzer_0, '1']
- [quantum_controllers_Coprocessor_0, '2', quantum_controllers_Analyzer_0, '2']
- [quantum_controllers_Coprocessor_0, out, quantum_controllers_Analyzer_0, in]
- [quantum_controllers_Generator_0, '0', quantum_measurements_Detector_0, '0']
- [quantum_controllers_Generator_0, out, quantum_measurements_Detector_0, in]
- [quantum_controllers_Initializer_0, out, quantum_gates_X_0, in]
- [quantum_controllers_QuTiP_Simulator_0, out, quantum_controllers_Generator_0, in]
- [quantum_controllers_QuTiP_Simulator_0, simulated_data, quantum_controllers_Generator_0, simulated_data]
- [quantum_controllers_readout_0, out, quantum_controllers_Coprocessor_0, in]
- [quantum_gates_X_0, out, quantum_controllers_readout_0, in]
- [quantum_measurements_Detector_0, result, quantum_viewer_QuTiP_Bloch_0, result]

metadata:
  file_format: 1
