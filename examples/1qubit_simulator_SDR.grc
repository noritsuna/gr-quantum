options:
  parameters:
    author: Noritsuna Imamura(noritsuna@siprop.org)
    generate_options: qt_gui
    id: one_qubit_simultor_SDR
    output_language: python
    title: Simple 1Qubit Simultor with SDR
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: quantum_controllers_Coprocessor_0
  id: quantum_controllers_Coprocessor
  parameters:
    qubit_id: '0'
    samples_per_second: samp_rate
    scale_rate: '1000000000.0'
    showSyncPort: 'True'
  states: {}
- name: quantum_controllers_Initializer_0
  id: quantum_controllers_Initializer
  parameters:
    I_amp: '0.007'
    I_bw: '30'
    Q_amp: '0.004'
    Q_bw: '50'
    freq: '1000'
    isFeedbackMode: 'False'
    proc_time: '3'
    qubit_id: '1'
    samples_per_second: samp_rate
  states: {}
- name: quantum_controllers_readout_0
  id: quantum_controllers_readout
  parameters:
    I_amp: '0.009'
    I_bw: '50'
    Q_amp: '0.07'
    Q_bw: '100'
    freq: '1500'
    proc_time: '6'
    samples_per_second: samp_rate
  states: {}
- name: quantum_gates_X_0
  id: quantum_gates_X
  parameters:
    I_amp: '0.08'
    I_bw: '60'
    Q_amp: '0.002'
    Q_bw: '100'
    freq: '1300'
    proc_time: '5'
    samples_per_second: samp_rate
  states: {}
- name: quantum_measurements_Detector_0
  id: quantum_measurements_Detector
  parameters:
    amp_threshold_rate: '10.0'
    bw_threshold_rate: '10.0'
    freq_threshold_rate: '10.0'
    proc_time_threshold_rate: '10.0'
    qubit_num: '1'
    qubit_pole: 'True'
    samples_per_second: samp_rate
    scale_rate: '1000000000.0'
  states: {}
- name: quantum_viewer_QuTiP_Bloch_0
  id: quantum_viewer_QuTiP_Bloch
  parameters:
    qubit_id: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '5300000000'
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: '5300000000'
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '1'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: '5300000000'
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '1'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [quantum_controllers_Coprocessor_0, '0', blocks_multiply_xx_0, '0']
- [quantum_controllers_Coprocessor_0, '1', blocks_multiply_xx_0, '1']
- [quantum_controllers_Coprocessor_0, '2', uhd_usrp_sink_1, '0']
- [quantum_controllers_Coprocessor_0, out, quantum_measurements_Detector_0, in]
- [quantum_controllers_Initializer_0, out, quantum_gates_X_0, in]
- [quantum_controllers_readout_0, out, quantum_controllers_Coprocessor_0, in]
- [quantum_gates_X_0, out, quantum_controllers_readout_0, in]
- [quantum_measurements_Detector_0, result, quantum_viewer_QuTiP_Bloch_0, result]
- [uhd_usrp_source_0, '0', quantum_measurements_Detector_0, '0']

metadata:
  file_format: 1
